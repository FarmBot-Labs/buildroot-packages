## Config.in
```kconfig
menu "Farmbot Packages"

source "$NERVES_DEFCONFIG_DIR/buildroot-packages/opencvfb/Config.in"

endmenu
```
